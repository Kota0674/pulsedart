## fw/boards/hyperx/pulsedart/board.yml
```yaml
board:
  name: pulsedart
  full_name: HyperX Pulsefire Dart (nRF52840)
  vendor: hyperx
  socs:
    - name: nrf52840
```
